# Repository alltheworld/tp4056

File README.md:

# tp4056
TP4056 charger kicad schematics

Kicad version with tp4056 footprint and schematics

TP4056 battery charging module with protection.  KICAD v6. old version for KICAD v5.

Charging current set to 130ma (R=10kOm)

tp4056 for DIY hand soldering with microUSB.

## KiCad design tp4056_kicad6_base/tp4056.kicad_pcb

Parts:
C1, C3: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: USB_B_Micro; tp4056_USB_Micro-B_Molex_47346-0001_fix
J2, J3, J4, J5, J6, J7: Conn_01x01_Female; PinSocket_1x01_P2.54mm_Vertical
R1, R2, R4: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 0R; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
U1: TP4056; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm
U2: DW01; SOT-23-6_Handsoldering
U3: FS8205A; SOT-23-6_Handsoldering

Connections:
/G1: U2.1 (OD), U3.6 (G1)
/G2: R6.2, U3.4 (G2)
/OC: R6.1, U2.3 (OC)
BAT+: C2.1, J6.1, J7.1, R5.1, U1.5 (BAT)
BAT-: C3.2, J4.1, U2.6 (GND), U3.1 (S1)
GND: C1.2, C2.2, J1.5 (GND), J2.1, J5.1, R3.2, R4.1, U1.1 (TEMP), U1.3 (GND), U3.3 (S2)
unnamed: C3.1, R5.2, U2.5 (VCC)
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: R1.2, U1.7 (~CHRG)
unnamed: R2.2, U1.6 (~STDBY)
unnamed: R3.1, U1.2 (PROG)
unnamed: R4.2, U2.2 (CS)
VIN: C1.1, D1.2 (A), D2.2 (A), J1.1 (VBUS), J3.1, U1.4 (VCC), U1.8 (CE), U1.9 (PP)

Notes on the sheet:
Ceramic Cap.
R3 set chargin current 10k = 130 ma

Board: 2 copper layers, 41.8 x 20.5 mm, 21 parts (0 on the bottom side), 14 nets.

## Commit log

2017-08-26 add files
2017-08-26 add readme
2022-03-25 kicad v6 and microusb footprint
2022-03-25 readme update
